# Keil uVision project code.uvprojx, settings and files
target code (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: code +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RBT7, USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\app;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/rvds/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c wk_system.c wk_adc.c wk_debug.c wk_exint.c wk_tmr.c wk_usart.c wk_gpio.c wk_dma.c freertos_app.c include_port.c
  group firmware
    ../../libraries/drivers/src/: at32f415_adc.c at32f415_crm.c at32f415_debug.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_tmr.c at32f415_usart.c at32f415_dma.c at32f415_spi.c at32f415_cmp.c at32f415_ertc.c at32f415_i2c.c at32f415_crc.c at32f415_wwdt.c at32f415_wdt.c at32f415_usb.c at32f415_can.c at32f415_sdio.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ./: startup_at32f415.s
  group app
    ../../app/: AT8236.c totolCtl.c current.c enc.c FT.c getBusVol.c moter28.c moter42.c moter57.c usrDebug.c tmux1308.c ws2812.c LED.c Tempurature.c
    ../../task/: modbusTask.c getState.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
